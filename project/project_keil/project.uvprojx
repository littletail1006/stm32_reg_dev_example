# Keil uVision project project.uvprojx, settings and files
target project_template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c misc: --no-multibyte-chars
  c include: ..\..\driver\drv_dev\include;..\..\common\include;..\..\driver\drv_per\include;..\..\component\mini_printf\mini-printf;..\..\component\ring_buffer\lwrb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../../app/: main.c example.c
  group component
    ../../component/mini_printf/lwprintf/: lwprintf.c
    ../../component/mini_printf/mini-printf/: mini-printf.c
    ../../component/ring_buffer/lwrb/: lwrb.c
  group common
    ../../common/source/: common.c
  group driver_per
    ../../driver/drv_per/source/: usart.c dma.c i2c.c i2c_io.c tim.c adc.c wdg.c rtc.c
  group driver_dev
    ../../driver/drv_dev/source/: led.c key.c oled.c
  group startup
    ./startup/: startup_stm32f10x_md.s
